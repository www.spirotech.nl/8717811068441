Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 807fb87b-aa6f-4c89-a289-2d4037f525e4, VersionGUID: 3e4af37f-2efe-4954-be40-42655ab79505, NumberOfSaves: 238]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6-400_INT-EN.ifc
Time: 2026-09-25T16:02:46+02:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (ENU) - IFC 24.3.40.26

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
V00 | V00 | 0
V01 | V01 | 3300
V02 | V02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6_INT-EN:EVU6-400, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6_INT-EN:EVU6-400:1335185
In: V00
Type - Material: Color RGB 040-040-040, Color RGB 251-203-029, Color RGB 168-168-168
Type - Other - Category: Mechanical Equipment; aa: 31 mm; Angle D: 180 deg; Array Radius: 235 mm; bb: 6.85141 mm; cc: 25 mm; Conector Distance: 30 mm; Connector Height: 110 mm; Connector Length: 48.5 mm; Connector Offset: 130 mm; D-1: 600 mm; D2: 300 mm; dd: 250 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6_INT-EN; H-1: 1630 mm; H2: 1630 mm; Height Logo: 113 mm; Leg 7-1: yes; Logo_80: no; Logo 300: yes; Nominal Diameter: 25.4 mm; Outer Diameter: 33.7 mm; Q: 85 mm; R1-1: 120 mm; Ring: 164.8 mm; R-Logo: 300.5 mm; t-2: 230 mm; Tall Diameter: 600 mm; Tall Height: 1630 mm; Vassel 120-300: yes; Vassel 15-60: no; Vassel Logo Height: 243.86 mm; Vassel Second Ring: no; Vassel Top: no; Vessel Bottom: 85 mm; Vessel Ring Bottom: 117 mm; Vessel Ring Top: 117 mm; Vessel Top: 102 mm; Void Logo 1: 600 mm; Void Logo 2: 600 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 25.4 mm; Diameter: 600 mm; Height: 1630 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Identity Data - Article Type: EVU6-400; Base Family Version: 26.10; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: EVU-6 bar Expansion vessel 400L standing; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 26.10; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer URL: https://www.spirotech.com/products/spiroexpand-expansion-vessels/spiroexpand-evu-6-bar-299?variant=2154; MEPcontent Class: EXPANSIONVESSEL; Model: EVU6-400; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Revit Version: 2024; Type Name: EVU6-400; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 040-040-040; Grey: Color RGB 168-168-168; Yellow: Color RGB 251-203-029
Type - Mechanical - Connection Pipe Type: External thread conical BSPT-R (ISO 7-1 / EN 10226-1) (EV020238); Horizontal Positioning: No; Material Membrane/Bladder: Ethylene-propylene diene monomer rubber (EPDM) (EV006730); Maximum Gas Pre-Pressure: 350000 Pa; Maximum Glycol Mixture: 50%; Maximum Medium Temperature: 70 C; Minimum Medium Temperature: -10 C; Nominal Diameter, Expansion Connection: DN 25 (EV005374); Outer Pipe Diameter, Expansion Connection: 33.2 mm; Suitable for Central Heating: yes; Suitable for Cooling: yes; Suitable for Solar Collector Circuit: yes; Suitable for Tap Water: no; Tilting Height: 1670 mm; With Drain: Yes; With Exchangeable Membrane: No; With Fixed Wall Support: No; With Mounting Material: No; With Vessel Manifold: No
Type - Mechanical - Flow - Maximum Operating Pressure: 600000 Pa
Type - Plumbing - Volume: 0.4 m3
Type - Text - Article Description: EVU-6 bar Expansion vessel 400L standing; GTIN: 8717811068441; Manufacturer Art. No.: EVU6-400; Pipe Type Category: M561; Product Line: Spirotech
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EVU6-400; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EVU6-400
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVU6_INT-EN: EVU6-400; Type: EVU6-400; Type Id: 1335104
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 3.58364 m2; Volume: 0.849829 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow: 0 m3/s
Phasing - Phase Created: 4. Plan over 10 jaar

# IfcDistributionPort, InPort_1335185_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE
